# Keil uVision project GD32107C_EVAL.uvproj, settings and files
target GD32107C_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F103RC GigaDevice
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x08000000-0x0803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GD32107C_EVAL +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD
  c include: ..\Library\Firmware\GD32F10x_standard_peripheral\Include;..\Library\Utilities;..\Library\Firmware\CMSIS;..\Library\Firmware\CMSIS\GD\GD32F10x\Include;..\inc;..\Third_party\lwip-2.0.2\src\include;..\Third_party\lwip-2.0.2\port\GD32F10x;..\Third_party\lwip-2.0.2\port\GD32F10x\FreeRTOS;..\Third_party\FreeRTOS-8.2.3\include;..\Third_party\FreeRTOS-8.2.3\portable\RVDS\ARM_CM3;..\src\y138\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ../src/: main.c gd32f10x_it.c
    ../src/y138/: gd32f10x_hal.c
  group CMSIS
    ../Library/Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group GD32F10x_Peripherals
    ../Library/Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_bkp.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_timer.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group GD32F10x_EVAL
    ../Library/Utilities/: gd32f107c_eval.c
  group FreeRTOS
    ../Third_party/FreeRTOS-8.2.3/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Third_party/FreeRTOS-8.2.3/portable/RVDS/ARM_CM3/: port.c
    ../Third_party/FreeRTOS-8.2.3/portable/MemMang/: heap_2.c
  group Startup
    ../Library/Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_hd.s
  group Doc
    ../: readme.txt
  group User
    ../src/y138/: hal_uart_ctrl.c hal_servo_ctrl.c hal_gpio_ctrl.c hal_timer_ctrl.c hal_i2c_ctrl.c hal_breath_light.c hal_pwm_ctrl.c hal_rs485_ctrl.c hal_tp_ctrl.c hal_drv_test.c hal_it_ctrl.c hal_rk_ctrl.c
  group inc
    ../inc/: FreeRTOSConfig.h gd32f10x_enet_eval.h gd32f10x_it.h gd32f10x_libopt.h hello_gigadevice.h lwipopts.h main.h netconf.h tcp_client.h udp_echo.h
    ../src/y138/include/: type.h hal_servo_cfg.h public.h
